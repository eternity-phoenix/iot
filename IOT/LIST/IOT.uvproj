# Keil uVision project IOT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IOT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\UART;..\DHT11;..\ESP8266;..\MAIN
  group Source Group 1
    ./: STARTUP.A51
  group MAIN
    ../MAIN/: main.c
  group ESP8266
    ../ESP8266/: ESP8266.c
  group DHT11
    ../DHT11/: DHT11.c
  group UART
    ../UART/: UART.c
  group HEAD
    ../ESP8266/: ESP8266.h
    ../UART/: UART.h
    ../DHT11/: DHT11.h
